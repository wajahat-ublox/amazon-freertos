# Keil uVision project aws_tests.uvprojx, settings and files
target c030_r412m (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F437VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: aws_tests +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: MBEDTLS_CONFIG_FILE="<aws_mbedtls_config.h>" MBEDTLS_USER_CONFIG_FILE=\"mbedtls_user_config.h\" CONFIG_MEDTLS_USE_AFR_MEMORY __LITTLE_ENDIAN__ FREERTOS_ENABLE_UNIT_TESTS __little_endian__=1 NDEBUG UNITY_INCLUDE_CONFIG_H AMAZON_FREERTOS_ENABLE_UNIT_TESTS USE_HAL_DRIVER STM32F437xx
  c include: ..\..\..\..\..\vendors\ublox\boards\c030_r412m\aws_tests\config_files;..\..\..\..\..\freertos_kernel\include;../../../../../libraries/freertos_plus/standard/crypto/include;../../../../../tests/include;../../../../../libraries/c_sdk/standard/common/include/private;../../../../../libraries/c_sdk/standard/common/include;../../../../../libraries/abstractions/platform/include;../../../../../libraries/abstractions/platform/freertos/include;../../../../../libraries/abstractions/platform/include/platform;../../../../../libraries/abstractions/secure_sockets/include;../../../../../libraries/freertos_plus/standard/tls/include;../../../../../libraries/abstractions/pkcs11/corePKCS11/source/include;../../../../../libraries/freertos_plus/aws/ota/test;../../../../../libraries/freertos_plus/standard/utils/include;../../../../../libraries/abstractions/wifi/include;../../../../../libraries/logging/include;../../../../../libraries/c_sdk/aws/defender/include;../../../../../libraries/c_sdk/aws/defender/src;../../../../../libraries/c_sdk/standard/mqtt/test/access;../../../../../libraries/c_sdk/standard/mqtt/test/mock;../../../../../libraries/c_sdk/standard/mqtt/include;../../../../../libraries/c_sdk/standard/mqtt/src;../../../../../libraries/coreMQTT/source/include;../../../../../libraries/coreMQTT/source/portable;../../../../../libraries/c_sdk/standard/serializer/include;../../../../../libraries/c_sdk/aws/shadow/include;../../../../../libraries/c_sdk/aws/shadow/src;../../../../../libraries/c_sdk/standard/https/test/access;../../../../../libraries/c_sdk/standard/https/include;../../../../../libraries/c_sdk/standard/https/src;../../../../../libraries/freertos_plus/aws/greengrass/test;../../../../../libraries/freertos_plus/aws/greengrass/include;../../../../../libraries/freertos_plus/aws/greengrass/src;../../../../../libraries/freertos_plus/standard/freertos_plus_cli/include;../../../../../libraries/abstractions/retry_utils;../../../../../libraries/abstractions/transport/secure_sockets;../../../../../libraries/coreJSON/source/include;../../../../../libraries/device_shadow_for_aws_iot_embedded_sdk/source/include;../../../../../libraries/3rdparty/pkcs11;../../../../../libraries/3rdparty/mbedtls/include;../../../../../libraries/abstractions/pkcs11/corePKCS11/source/portable/mbedtls/include;../../../../../libraries/3rdparty/mbedtls/include/mbedtls;../../../../../libraries/3rdparty/mbedtls_utils;../../../../../libraries/3rdparty/mbedtls_config;../../../../../libraries/3rdparty/unity/src;../../../../../libraries/3rdparty/unity/extras/fixture/src;../../../../../libraries/3rdparty/tinycbor/src;../../../../../libraries/3rdparty/http_parser;../../../../../libraries/3rdparty/jsmn;..\..\..\..\..\freertos_kernel\portable\RVDS\ARM_CM4F;..\..\..\..\..\vendors\ublox\boards\c030_r412m\aws_tests\application_code;..\..\..\..\..\vendors\ublox\boards\c030_r412m\aws_tests\application_code\st_code;..\..\..\..\..\vendors\ublox\sdk\CMSIS\Include;..\..\..\..\..\vendors\ublox\sdk\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\vendors\ublox\sdk\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\demos\dev_mode_key_provisioning\include;..\..\..\..\..\libraries\abstractions\common_io\include;..\..\..\..\..\libraries\abstractions\common_io\test
  memory RVCT4: ROM 0x8000000 size 0xe0000
  memory RVCT5: ROM 0x80e0000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\..\..\..\..\vendors\ublox\boards\c030_r412m\aws_tests\c030_r412m.sct
  group application_code/
    ../../../../../vendors/ublox/boards/c030_r412m/aws_tests/application_code/: main.c
  group application_code/st_code
    ../../../../../vendors/ublox/boards/c030_r412m/aws_tests/application_code/st_code/: startup_stm32f437xx.s stm32f4xx_hal_conf.h stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c stm32f4xx_it.c stm32f4xx_it.h entropy_hardware_poll.c
  group config_files
    ../../../../../vendors/ublox/boards/c030_r412m/aws_tests/config_files/: FreeRTOSConfig.h aws_bufferpool_config.h aws_ggd_config.h aws_mqtt_config.h aws_ota_agent_config.h aws_secure_sockets_config.h aws_shadow_config.h aws_test_ota_config.h aws_test_runner_config.h aws_test_tcp_config.h aws_test_wifi_config.h aws_wifi_config.h core_mqtt_config.h core_pkcs11_config.h core_test_pkcs11_config.h FreeRTOSIPConfig.h iot_config.h iot_mqtt_agent_config.h iot_test_common_io_config.h shadow_config.h trcConfig.h trcSnapshotConfig.h unity_config.h
  group vendors/ublox/boards/c030_r412m/ports/secure_sockets/
    ../../../../../vendors/ublox/boards/c030_r412m/ports/secure_sockets/: iot_secure_sockets.c
  group vendors/ublox/boards/c030_r412m/ports/pkcs11/
    ../../../../../vendors/ublox/boards/c030_r412m/ports/pkcs11/: core_pkcs11_pal.c
  group vendors/ublox/boards/c030_r412m/ports/common_io/
    ../../../../../vendors/ublox/boards/c030_r412m/ports/common_io/: iot_test_common_io_internal.c iot_uart.c
  group vendors/ublox/boards/sdk/CMSIS
    ../../../../../vendors/ublox/sdk/CMSIS/: system_stm32f4xx.c
  group vendors/ublox/boards/sdk/CMSIS/Include
    ../../../../../vendors/ublox/sdk/CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_compiler.h cmsis_gcc.h cmsis_version.h core_cm0.h core_cm0plus.h core_cm1.h core_cm3.h core_cm4.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h
  group vendors/ublox/boards/sdk/CMSIS/Device/ST/STM32F4xx/include
    ../../../../../vendors/ublox/sdk/CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h stm32f437xx.h system_stm32f4xx.h
  group vendors/ublox/boards/sdk/STM32F4xx_HAL_Driver/Inc/
    ../../../../../vendors/ublox/sdk/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal.h stm32f4xx_hal_cortex.h stm32f4xx_hal_exti.h stm32f4xx_hal_gpio.h stm32f4xx_hal_pwr.h stm32f4xx_hal_rcc.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h stm32f4xx_hal_uart.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h
  group vendors/ublox/boards/sdk/STM32F4xx_HAL_Driver/Src/
    ../../../../../vendors/ublox/sdk/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_exti.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_rng.c
  group tests/include/
    ../../../../../tests/include/: aws_application_version.h aws_clientcredential.h aws_clientcredential_keys.h aws_test_framework.h aws_test_runner.h aws_test_tcp.h aws_test_utils.h aws_unity_config.h iot_config_common.h
  group tests/common/
    ../../../../../tests/common/: aws_test.c aws_test_framework.c aws_test_runner.c iot_test_freertos.c iot_tests_network.c
  group tests/integration_test/
    ../../../../../tests/integration_test/: core_mqtt_system_test.c shadow_system_test.c
  group freertos_kernel/
    ../../../../../freertos_kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos_kernel/portable/MemMang/
    ../../../../../freertos_kernel/portable/MemMang/: heap_4.c
  group freertos_kernel/portable/RVDS/ARM_CM4F/
    ../../../../../freertos_kernel/portable/RVDS/ARM_CM4F/: port.c
  group libraries/abstractions/common_io/include/
    ../../../../../libraries/abstractions/common_io/include/: iot_uart.h
  group libraries/c_sdk/standard/common/
    ../../../../../libraries/c_sdk/standard/common/: iot_device_metrics.c iot_init.c iot_static_memory_common.c
  group libraries/c_sdk/standard/common/include/
    ../../../../../libraries/c_sdk/standard/common/include/: iot_appversion32.h iot_atomic.h iot_init.h iot_linear_containers.h iot_logging_setup.h iot_taskpool.h
  group libraries/c_sdk/standard/common/include/types/
    ../../../../../libraries/c_sdk/standard/common/include/types/: iot_network_types.h iot_taskpool_types.h
  group libraries/c_sdk/standard/common/taskpool/
    ../../../../../libraries/c_sdk/standard/common/taskpool/: iot_taskpool.c iot_taskpool_static_memory.c
  group libraries/c_sdk/standard/common/include/private/
    ../../../../../libraries/c_sdk/standard/common/include/private/: iot_default_root_certificates.h iot_doubly_linked_list.h iot_error.h iot_lib_init.h iot_logging.h iot_static_memory.h iot_taskpool_internal.h
  group libraries/abstractions/platform/include/platform/
    ../../../../../libraries/abstractions/platform/include/platform/: iot_clock.h iot_metrics.h iot_network.h iot_threads.h transport_interface.h
  group libraries/abstractions/platform/include/types/
    ../../../../../libraries/abstractions/platform/include/types/: iot_platform_types.h
  group libraries/abstractions/platform/freertos/
    ../../../../../libraries/abstractions/platform/freertos/: iot_clock_freertos.c iot_metrics.c iot_network_freertos.c iot_threads_freertos.c
  group libraries/abstractions/platform/freertos/include/platform/
    ../../../../../libraries/abstractions/platform/freertos/include/platform/: iot_network_ble.h iot_network_freertos.h iot_platform_types_freertos.h
  group libraries/abstractions/secure_sockets/include/
    ../../../../../libraries/abstractions/secure_sockets/include/: iot_secure_sockets.h iot_secure_sockets_config_defaults.h iot_secure_sockets_wrapper_metrics.h
  group libraries/freertos_plus/standard/tls/src/
    ../../../../../libraries/freertos_plus/standard/tls/src/: iot_tls.c
  group libraries/freertos_plus/standard/tls/include/
    ../../../../../libraries/freertos_plus/standard/tls/include/: iot_tls.h
  group libraries/freertos_plus/standard/crypto/src/
    ../../../../../libraries/freertos_plus/standard/crypto/src/: iot_crypto.c
  group libraries/freertos_plus/standard/crypto/include/
    ../../../../../libraries/freertos_plus/standard/crypto/include/: iot_crypto.h
  group libraries/abstractions/pkcs11/corePKCS11/source/include/
    ../../../../../libraries/abstractions/pkcs11/corePKCS11/source/include/: core_pkcs11.h core_pkcs11_pal.h core_pki_utils.h
  group libraries/abstractions/pkcs11/corePKCS11/source/
    ../../../../../libraries/abstractions/pkcs11/corePKCS11/source/: core_pkcs11.c core_pki_utils.c
  group libraries/abstractions/pkcs11/corePKCS11/source/portable/mbedtls/
    ../../../../../libraries/abstractions/pkcs11/corePKCS11/source/portable/mbedtls/: core_pkcs11_mbedtls.c
  group libraries/abstractions/pkcs11/corePKCS11/source/portable/mbedtls/include/
    ../../../../../libraries/abstractions/pkcs11/corePKCS11/source/portable/mbedtls/include/: threading_alt.h
  group libraries/freertos_plus/standard/utils/src/
    ../../../../../libraries/freertos_plus/standard/utils/src/: iot_system_init.c
  group libraries/freertos_plus/standard/utils/include/
    ../../../../../libraries/freertos_plus/standard/utils/include/: iot_system_init.h
  group libraries/logging/
    ../../../../../libraries/logging/: iot_logging.c iot_logging_task_dynamic_buffers.c
  group libraries/logging/include/
    ../../../../../libraries/logging/include/: iot_logging_task.h logging_levels.h logging_stack.h
  group libraries/c_sdk/aws/defender/src/
    ../../../../../libraries/c_sdk/aws/defender/src/: aws_iot_defender_api.c aws_iot_defender_collector.c aws_iot_defender_mqtt.c aws_iot_defender_v1.c
  group libraries/c_sdk/aws/defender/src/private/
    ../../../../../libraries/c_sdk/aws/defender/src/private/: aws_iot_defender_internal.h
  group libraries/c_sdk/aws/defender/include/
    ../../../../../libraries/c_sdk/aws/defender/include/: aws_defender.h aws_iot_defender.h
  group libraries/c_sdk/standard/mqtt/src/
    ../../../../../libraries/c_sdk/standard/mqtt/src/: iot_mqtt_agent.c iot_mqtt_api.c iot_mqtt_context_connection.c iot_mqtt_managed_function_wrapper.c iot_mqtt_mutex_wrapper.c iot_mqtt_network.c iot_mqtt_operation.c iot_mqtt_publish_duplicates.c iot_mqtt_serializer_deserializer_wrapper.c iot_mqtt_static_memory.c iot_mqtt_subscription.c iot_mqtt_subscription_container.c iot_mqtt_validate.c
  group libraries/coreMQTT/source/
    ../../../../../libraries/coreMQTT/source/: core_mqtt.c core_mqtt_serializer.c core_mqtt_state.c
  group libraries/coreMQTT/source/include/
    ../../../../../libraries/coreMQTT/source/include/: core_mqtt.h core_mqtt_config_defaults.h core_mqtt_serializer.h core_mqtt_state.h
  group libraries/coreMQTT/source/portable/
    ../../../../../libraries/coreMQTT/source/portable/: transport_interface.h
  group libraries/c_sdk/standard/serializer/src/cbor/
    ../../../../../libraries/c_sdk/standard/serializer/src/cbor/: iot_serializer_tinycbor_decoder.c iot_serializer_tinycbor_encoder.c
  group libraries/c_sdk/standard/serializer/src/json/
    ../../../../../libraries/c_sdk/standard/serializer/src/json/: iot_serializer_json_decoder.c iot_serializer_json_encoder.c
  group libraries/c_sdk/standard/serializer/src/
    ../../../../../libraries/c_sdk/standard/serializer/src/: iot_json_utils.c iot_serializer_static_memory.c
  group libraries/c_sdk/standard/serializer/include/
    ../../../../../libraries/c_sdk/standard/serializer/include/: iot_json_utils.h iot_serializer.h
  group libraries/c_sdk/aws/shadow/src/
    ../../../../../libraries/c_sdk/aws/shadow/src/: aws_iot_shadow_api.c aws_iot_shadow_operation.c aws_iot_shadow_parser.c aws_iot_shadow_static_memory.c aws_iot_shadow_subscription.c aws_shadow.c aws_shadow_config_defaults.h
  group libraries/c_sdk/aws/shadow/include/
    ../../../../../libraries/c_sdk/aws/shadow/include/: aws_iot_shadow.h aws_shadow.h
  group libraries/c_sdk/standard/https/src/
    ../../../../../libraries/c_sdk/standard/https/src/: iot_https_client.c iot_https_utils.c
  group libraries/freertos_plus/aws/greengrass/src/
    ../../../../../libraries/freertos_plus/aws/greengrass/src/: aws_greengrass_discovery.c aws_helper_secure_connect.c aws_helper_secure_connect.h
  group libraries/freertos_plus/aws/greengrass/include/
    ../../../../../libraries/freertos_plus/aws/greengrass/include/: aws_ggd_config_defaults.h aws_greengrass_discovery.h
  group libraries/freertos_plus/standard/freertos_plus_cli/source/
    ../../../../../libraries/freertos_plus/standard/freertos_plus_cli/source/: FreeRTOS_CLI.c FreeRTOS_CLI_Console.c
  group libraries/abstractions/retry_utils/freertos/
    ../../../../../libraries/abstractions/retry_utils/freertos/: retry_utils_freertos.c
  group libraries/abstractions/retry_utils/
    ../../../../../libraries/abstractions/retry_utils/: retry_utils.h
  group libraries/abstractions/transport/secure_sockets/
    ../../../../../libraries/abstractions/transport/secure_sockets/: transport_secure_sockets.c transport_secure_sockets.h
  group libraries/coreJSON/source/
    ../../../../../libraries/coreJSON/source/: core_json.c
  group libraries/device_shadow_for_aws_iot_embedded_sdk/source/
    ../../../../../libraries/device_shadow_for_aws_iot_embedded_sdk/source/: shadow.c
  group libraries/c_sdk/aws/defender/test/unit/
    ../../../../../libraries/c_sdk/aws/defender/test/unit/: aws_iot_tests_defender_unit.c
  group libraries/c_sdk/aws/defender/test/system/
    ../../../../../libraries/c_sdk/aws/defender/test/system/: aws_iot_tests_defender_system.c
  group libraries/c_sdk/aws/shadow/test/unit/
    ../../../../../libraries/c_sdk/aws/shadow/test/unit/: aws_iot_tests_shadow_api.c aws_iot_tests_shadow_parser.c
  group libraries/c_sdk/aws/shadow/test/system/
    ../../../../../libraries/c_sdk/aws/shadow/test/system/: aws_iot_tests_shadow_system.c
  group libraries/c_sdk/aws/shadow/test/
    ../../../../../libraries/c_sdk/aws/shadow/test/: aws_test_shadow.c
  group libraries/c_sdk/standard/common/test/
    ../../../../../libraries/c_sdk/standard/common/test/: iot_memory_leak.c iot_tests_taskpool.c
  group libraries/c_sdk/standard/https/test/unit/
    ../../../../../libraries/c_sdk/standard/https/test/unit/: iot_tests_https_async.c iot_tests_https_client.c iot_tests_https_common.c iot_tests_https_common.h iot_tests_https_sync.c iot_tests_https_utils.c
  group libraries/c_sdk/standard/https/test/system/
    ../../../../../libraries/c_sdk/standard/https/test/system/: iot_tests_https_system.c
  group libraries/c_sdk/standard/mqtt/test/mock/
    ../../../../../libraries/c_sdk/standard/mqtt/test/mock/: iot_tests_mqtt_mock.c iot_tests_mqtt_mock.h
  group libraries/c_sdk/standard/mqtt/test/unit/
    ../../../../../libraries/c_sdk/standard/mqtt/test/unit/: iot_tests_mqtt_api.c iot_tests_mqtt_metrics.c iot_tests_mqtt_receive.c iot_tests_mqtt_subscription.c iot_tests_mqtt_validate.c
  group libraries/c_sdk/standard/mqtt/test/system/
    ../../../../../libraries/c_sdk/standard/mqtt/test/system/: iot_tests_mqtt_system.c
  group libraries/c_sdk/standard/mqtt/test/
    ../../../../../libraries/c_sdk/standard/mqtt/test/: iot_test_mqtt_agent.c
  group libraries/c_sdk/standard/serializer/test/
    ../../../../../libraries/c_sdk/standard/serializer/test/: iot_tests_deserializer_json.c iot_tests_serializer_cbor.c iot_tests_serializer_json.c
  group libraries/freertos_plus/aws/greengrass/test/
    ../../../../../libraries/freertos_plus/aws/greengrass/test/: aws_greengrass_discovery_test_access_declare.h aws_greengrass_discovery_test_access_define.h aws_test_ggd_system.c aws_test_ggd_unit.c aws_test_helper_secure_connect.c
  group libraries/freertos_plus/standard/crypto/test/
    ../../../../../libraries/freertos_plus/standard/crypto/test/: iot_test_crypto.c
  group libraries/freertos_plus/standard/freertos_plus_cli/utest/
    ../../../../../libraries/freertos_plus/standard/freertos_plus_cli/utest/: iot_test_freertos_cli.c iot_test_freertos_cli_console.c
  group libraries/freertos_plus/standard/tls/test/
    ../../../../../libraries/freertos_plus/standard/tls/test/: iot_test_tls.c iot_test_tls.h
  group libraries/abstractions/pkcs11/test/
    ../../../../../libraries/abstractions/pkcs11/test/: iot_test_pkcs11.c iot_test_pkcs11_globals.h
  group libraries/abstractions/platform/test/
    ../../../../../libraries/abstractions/platform/test/: iot_test_platform_clock.c iot_test_platform_threads.c
  group libraries/abstractions/secure_sockets/test/
    ../../../../../libraries/abstractions/secure_sockets/test/: iot_test_tcp.c
  group libraries/3rdparty/mbedtls/library/
    ../../../../../libraries/3rdparty/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group libraries/3rdparty/mbedtls/include/mbedtls/
    ../../../../../libraries/3rdparty/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md_internal.h md2.h md4.h md5.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs5.h pkcs11.h pkcs12.h platform.h platform_time.h platform_util.h poly1305.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group libraries/3rdparty/mbedtls_utils/
    ../../../../../libraries/3rdparty/mbedtls_utils/: mbedtls_error.c mbedtls_error.h mbedtls_utils.c
  group libraries/3rdparty/pkcs11/
    ../../../../../libraries/3rdparty/pkcs11/: pkcs11.h pkcs11f.h pkcs11t.h
  group libraries/3rdparty/unity/src/
    ../../../../../libraries/3rdparty/unity/src/: unity.c unity.h unity_internals.h
  group libraries/3rdparty/unity/extras/fixture/src/
    ../../../../../libraries/3rdparty/unity/extras/fixture/src/: unity_fixture.c unity_fixture.h unity_fixture_internals.h unity_fixture_malloc_overrides.h
  group libraries/3rdparty/tinycbor/src/
    ../../../../../libraries/3rdparty/tinycbor/src/: cborencoder.c cborencoder_close_container_checked.c cborerrorstrings.c cborparser.c cborparser_dup_string.c cborpretty.c cborpretty_stdio.c
  group libraries/3rdparty/http_parser/
    ../../../../../libraries/3rdparty/http_parser/: http_parser.c http_parser.h
  group libraries/3rdparty/jsmn/
    ../../../../../libraries/3rdparty/jsmn/: jsmn.c jsmn.h
  group demos/dev_mode_key_provisioning/src/
    ../../../../../demos/dev_mode_key_provisioning/src/: aws_dev_mode_key_provisioning.c
  group demos/dev_mode_key_provisioning/include/
    ../../../../../demos/dev_mode_key_provisioning/include/: aws_dev_mode_key_provisioning.h
